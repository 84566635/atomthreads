# IAR project atomthreads-sample-iar.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105; ATOM_STACK_CHECKING
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: stm8s-periphs; ..\ports\stm8; ..\..\kernel; .\
  ICCSTM8.IccLang: 0
  ASTM8.AsmIncludePath: .\
  OBJCOPY.OOCOutputFile: atomthreads-sample-iar.srec
  ILINK.IlinkOutputFile: atomthreads.out
  ILINK.IlinkIcfFile: lnkstm8s105k4.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  ICCSTM8.CCDefines: NDEBUG; STM8S105
  group kernel
    ../../kernel/: atom.h atomkernel.c atommutex.c atommutex.h atomqueue.c atomqueue.h atomsem.c atomsem.h atomtimer.c atomtimer.h
  group stm8
    ./: atomport-asm-iar.s atomport-private.h atomport-tests.h atomport.c atomport.h cmain.c stm8s_conf.h uart.c uart.h
  group stm8s-periphs
    stm8s-periphs/: stm8s.h stm8s_adc1.c stm8s_adc1.h stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_clk.h stm8s_gpio.c stm8s_gpio.h stm8s_itc.c stm8s_itc.h stm8s_tim1.c stm8s_tim1.h stm8s_tim3.c stm8s_type.h stm8s_uart2.h
    STM8S-PERIPHS/: stm8s_uart2.c
